# Keil uVision project SmartTable.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartTable
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Drivers\include;..\Bsp;..\STM32F10x_StdPeriph_Driver\inc;..\Drivers\OLED;..\Drivers\qrcode;..\Drivers\wifi_esp8266;.\RTE\Device\STM32F103RE;..\Drivers\adc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group User
    ../Users/: stm32f10x_it.c main.c
  group Bsp
    ../Bsp/: bsp.c Buttons.c bsp_leds.c sys_tick_delay.c usb_contrl.c
  group Driver
    ../Drivers/OLED/: oled.c
    ../Drivers/adc/: sys_adc.c
    ../Drivers/sht1x/: sht1x.c
  group esp_wifi
    ../Drivers/wifi_esp8266/: wifi_esp.c wifi_esp_config.c
  group Common
    ../Common/: encryption.c
  group qrcodelib
    ../Drivers/qrcode/: QRCodeApp.c
    ../libqrencode/: bitstream.c mask.c mmask.c mqrspec.c qrenc.c qrencode.c qrinput.c qrspec.c rsecc.c split.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
